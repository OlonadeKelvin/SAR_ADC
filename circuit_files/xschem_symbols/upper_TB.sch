v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 830 -90 930 -90 {lab=V1n}
N 830 -110 830 -90 {lab=V1n}
N 910 -110 910 -70 {lab=V1p}
N 1030 15 1035 15 {lab=0}
N 90 -130 105 -130 {lab=VDD}
N 105 -245 105 -130 {lab=VDD}
N -565 60 -565 295 {lab=0}
N -300 210 -300 225 {lab=#net1}
N -350 145 -350 295 {lab=0}
N -225 70 -225 210 {lab=#net1}
N -390 215 -390 295 {lab=0}
N -565 -245 105 -245 {lab=VDD}
N -390 -130 -390 155 {lab=CLK_SH}
N -390 -130 -210 -130 {lab=CLK_SH}
N -350 -110 -350 85 {lab=notCLK_SH}
N -300 -90 -210 -90 {lab=Vinn}
N -300 -90 -300 150 {lab=Vinn}
N -225 -70 -210 -70 {lab=Vinp}
N -225 -70 -225 10 {lab=Vinp}
N -390 295 -350 295 {lab=0}
N -565 295 -390 295 {lab=0}
N -300 285 -300 295 {lab=0}
N -350 295 -300 295 {lab=0}
N -300 295 -225 295 {lab=0}
N 1145 -105 1255 -105 {lab=VR}
N 1140 -55 1255 -55 {lab=VL}
N -225 295 -225 310 {lab=0}
N -225 295 130 295 {lab=0}
N 130 -90 130 295 {lab=0}
N 90 -90 130 -90 {lab=0}
N 1295 -220 1295 -70 {lab=Vop}
N 1170 -70 1295 -70 {lab=Vop}
N 1270 -240 1270 -90 {lab=Von}
N 1170 -90 1270 -90 {lab=Von}
N 1270 -240 1310 -240 {lab=Von}
N 1040 -315 1040 -170 {lab=VDD}
N 1035 50 1350 50 {lab=0}
N 1035 15 1035 50 {lab=0}
N 1430 -475 1555 -475 {lab=Valid}
N 1420 -230 1430 -230 {lab=Valid}
N 1295 -70 1440 -70 {lab=Vop}
N 1270 -90 1445 -90 {lab=Von}
N 715 -110 830 -110 {lab=V1n}
N -565 -510 1350 -510 {lab=VDD}
N -235 -495 1555 -495 {lab=notCLK_SH}
N 695 -70 910 -70 {lab=V1p}
N 235 -185 235 -110 {lab=V1n}
N 410 -185 410 -110 {lab=V1n}
N 280 -110 360 -110 {lab=V1n}
N 1855 185 1970 185 {lab=P9_out}
N 1855 205 1970 205 {lab=P8_out}
N 1855 225 1970 225 {lab=P7_out}
N 1855 245 1970 245 {lab=P6_out}
N 1855 265 1970 265 {lab=P5_out}
N 1855 285 1970 285 {lab=P4_out}
N 1855 305 1970 305 {lab=P3_out}
N 1855 325 1970 325 {lab=P2_out}
N 1855 345 1970 345 {lab=P1_out}
N 1855 365 1970 365 {lab=P0_out}
N 1350 -315 1350 -290 {lab=VDD}
N 1445 -415 1445 -90 {lab=Von}
N 1440 -435 1440 -70 {lab=Vop}
N 1430 -475 1430 -230 {lab=Valid}
N 925 -130 930 -130 {lab=CLK_comp}
N 1855 385 1970 385 {lab=N9_out}
N 1855 405 1970 405 {lab=N8_out}
N 1855 425 1970 425 {lab=N7_out}
N 1855 445 1970 445 {lab=N6_out}
N 1855 465 1970 465 {lab=N5_out}
N 1855 485 1970 485 {lab=N4_out}
N 1855 505 1970 505 {lab=N3_out}
N 1855 525 1970 525 {lab=N2_out}
N 1855 545 1970 545 {lab=N1_out}
N 1855 565 1970 565 {lab=N0_out}
N 1400 35 1400 115 {lab=0}
N 1470 155 1470 235 {lab=0}
N 1400 -25 1535 -25 {lab=CLK_outputAll}
N -300 210 -225 210 {lab=#net1}
N -235 -110 -210 -110 {lab=notCLK_SH}
N -565 -245 -565 -0 {lab=VDD}
N 165 15 165 595 {lab=P9}
N 215 70 215 600 {lab=P8}
N 565 70 565 630 {lab=P2}
N 165 -70 165 -45 {lab=V1p}
N 90 -70 165 -70 {lab=V1p}
N 215 -70 215 10 {lab=V1p}
N 165 -70 215 -70 {lab=V1p}
N 260 -70 260 65 {lab=V1p}
N 215 -70 260 -70 {lab=V1p}
N 340 -70 340 -45 {lab=V1p}
N 260 -70 340 -70 {lab=V1p}
N 390 -70 390 10 {lab=V1p}
N 340 -70 390 -70 {lab=V1p}
N 435 -70 435 65 {lab=V1p}
N 390 -70 435 -70 {lab=V1p}
N 515 -70 515 -45 {lab=V1p}
N 435 -70 515 -70 {lab=V1p}
N 695 -70 695 -45 {lab=V1p}
N 610 -70 695 -70 {lab=V1p}
N 610 -70 610 65 {lab=V1p}
N 565 -70 610 -70 {lab=V1p}
N 565 -70 565 10 {lab=V1p}
N 515 -70 565 -70 {lab=V1p}
N 880 -130 925 -130 {lab=CLK_comp}
N -390 -455 -390 -130 {lab=CLK_SH}
N 585 -110 630 -110 {lab=V1n}
N 410 -110 455 -110 {lab=V1n}
N 535 -130 535 -110 {lab=V1n}
N 455 -110 535 -110 {lab=V1n}
N 535 -110 585 -110 {lab=V1n}
N 585 -185 585 -110 {lab=V1n}
N 715 -130 715 -110 {lab=V1n}
N 630 -110 715 -110 {lab=V1n}
N 360 -110 410 -110 {lab=V1n}
N 360 -130 360 -110 {lab=V1n}
N 185 -130 185 -110 {lab=V1n}
N 90 -110 185 -110 {lab=V1n}
N 185 -110 235 -110 {lab=V1n}
N -565 -510 -565 -245 {lab=VDD}
N 1350 -170 1350 50 {lab=0}
N 1295 -220 1310 -220 {lab=Vop}
N 1040 -315 1350 -315 {lab=VDD}
N 1350 -510 1350 -315 {lab=VDD}
N 280 -240 280 -110 {lab=V1n}
N 235 -110 280 -110 {lab=V1n}
N 630 -240 630 -110 {lab=V1n}
N 455 -240 455 -110 {lab=V1n}
N 1855 -475 1910 -475 {lab=0}
N 1910 -475 1910 -470 {lab=0}
N 1445 -415 1555 -415 {lab=Von}
N 1440 -435 1555 -435 {lab=Vop}
N 1535 -395 1555 -395 {lab=CLK_outputAll}
N 1855 -235 1890 -235 {lab=CLK_comp}
N 1890 -530 1890 -235 {lab=CLK_comp}
N 925 -530 1890 -530 {lab=CLK_comp}
N 925 -530 925 -130 {lab=CLK_comp}
N 1855 -550 1855 -495 {lab=VDD}
N 1350 -550 1855 -550 {lab=VDD}
N 1350 -550 1350 -510 {lab=VDD}
N 2245 -215 2245 595 {lab=P9}
N 165 595 2245 595 {lab=P9}
N 2250 -195 2250 600 {lab=P8}
N 260 125 260 605 {lab=P7}
N 2255 -175 2255 605 {lab=P7}
N 2260 -155 2260 610 {lab=P6}
N 340 15 340 610 {lab=P6}
N 390 70 390 615 {lab=P5}
N 390 615 2265 615 {lab=P5}
N 2265 -135 2265 615 {lab=P5}
N 2270 -115 2270 620 {lab=P4}
N 435 125 435 620 {lab=P4}
N 2275 -95 2275 625 {lab=P3}
N 515 15 515 625 {lab=P3}
N 2280 -75 2280 630 {lab=P2}
N 2285 -55 2285 635 {lab=P1}
N 610 125 610 635 {lab=P1}
N 695 15 695 640 {lab=P0}
N 695 640 2290 640 {lab=P0}
N 2290 -35 2290 640 {lab=P0}
N 2295 -570 2295 -15 {lab=N9}
N 185 -570 2295 -570 {lab=N9}
N 185 -570 185 -190 {lab=N9}
N 235 -575 235 -245 {lab=N8}
N 2300 -575 2300 5 {lab=N8}
N 280 -580 280 -300 {lab=N7}
N 2305 -580 2305 25 {lab=N7}
N 360 -585 360 -190 {lab=N6}
N 360 -585 2310 -585 {lab=N6}
N 2310 -585 2310 45 {lab=N6}
N 2315 -590 2315 65 {lab=N5}
N 410 -590 2315 -590 {lab=N5}
N 410 -590 410 -245 {lab=N5}
N 455 -595 455 -300 {lab=N4}
N 455 -595 2320 -595 {lab=N4}
N 2320 -595 2320 85 {lab=N4}
N 2325 -600 2325 105 {lab=N3}
N 535 -600 535 -190 {lab=N3}
N 585 -605 585 -245 {lab=N2}
N 585 -605 2330 -605 {lab=N2}
N 630 -610 630 -300 {lab=N1}
N 715 -615 715 -190 {lab=N0}
N 715 -615 2340 -615 {lab=N0}
N 2330 -605 2330 125 {lab=N2}
N 2335 -610 2335 145 {lab=N1}
N 1500 -455 1555 -455 {lab=CLK_SH}
N -235 -495 -235 -110 {lab=notCLK_SH}
N -350 -110 -235 -110 {lab=notCLK_SH}
N 1500 -455 1500 -355 {lab=CLK_SH}
N -390 -455 1500 -455 {lab=CLK_SH}
N 1515 -375 1555 -375 {lab=CLK_resetOut}
N 1535 -395 1535 -25 {lab=CLK_outputAll}
N 1500 -355 1555 -355 {lab=CLK_SH}
N 1515 -375 1515 95 {lab=CLK_resetOut}
N 1470 95 1515 95 {lab=CLK_resetOut}
N 1855 -455 2105 -455 {lab=Ck9}
N 1855 -435 2105 -435 {lab=Ck8}
N 1855 -415 2105 -415 {lab=Ck7}
N 1855 -395 2105 -395 {lab=Ck6}
N 1855 -375 2105 -375 {lab=Ck5}
N 1855 -355 2105 -355 {lab=Ck4}
N 1855 -335 2105 -335 {lab=Ck3}
N 1855 -315 2105 -315 {lab=Ck2}
N 1855 -295 2105 -295 {lab=Ck1}
N 1855 -275 2105 -275 {lab=Ck0}
N 2340 -615 2340 165 {lab=N0}
N 1855 -215 1875 -215 {lab=#net2}
N 1855 -195 1875 -195 {lab=#net3}
N 1855 -155 1875 -155 {lab=#net4}
N 1855 -175 1875 -175 {lab=#net5}
N 1855 -135 1875 -135 {lab=#net6}
N 1855 -115 1875 -115 {lab=#net7}
N 1855 -95 1875 -95 {lab=#net8}
N 1855 -75 1875 -75 {lab=#net9}
N 1855 -55 1875 -55 {lab=#net10}
N 1855 -35 1875 -35 {lab=#net11}
N 2035 -215 2245 -215 {lab=P9}
N 2035 -195 2250 -195 {lab=P8}
N 2035 -175 2255 -175 {lab=P7}
N 2035 -155 2260 -155 {lab=P6}
N 2035 -115 2270 -115 {lab=P4}
N 2035 -95 2275 -95 {lab=P3}
N 2035 -75 2280 -75 {lab=P2}
N 2035 -55 2285 -55 {lab=P1}
N 2035 -35 2290 -35 {lab=P0}
N 2195 -15 2295 -15 {lab=N9}
N 2195 5 2300 5 {lab=N8}
N 2195 25 2305 25 {lab=N7}
N 2195 45 2310 45 {lab=N6}
N 2195 65 2315 65 {lab=N5}
N 2195 85 2320 85 {lab=N4}
N 1855 -15 2035 -15 {lab=#net12}
N 1855 5 2035 5 {lab=#net13}
N 1855 25 2035 25 {lab=#net14}
N 1855 45 2035 45 {lab=#net15}
N 1855 65 2035 65 {lab=#net16}
N 1855 85 2035 85 {lab=#net17}
N 1855 165 2035 165 {lab=#net18}
N 1850 145 2035 145 {lab=#net19}
N 1855 125 2035 125 {lab=#net20}
N 1855 105 2035 105 {lab=#net21}
N 2195 165 2340 165 {lab=N0}
N 2195 125 2330 125 {lab=N2}
N 2195 145 2335 145 {lab=N1}
N 2195 105 2325 105 {lab=N3}
N 2035 -225 2195 -225 {lab=VDD}
N 2195 -225 2195 -25 {lab=VDD}
N 2195 210 2195 255 {lab=0}
N 2035 -25 2045 -25 {lab=0}
N 2045 -25 2045 210 {lab=0}
N 2045 210 2195 210 {lab=0}
N 2195 175 2195 210 {lab=0}
N 630 -610 2335 -610 {lab=N1}
N 535 -600 2325 -600 {lab=N3}
N 235 -575 2300 -575 {lab=N8}
N 280 -580 2305 -580 {lab=N7}
N 215 600 2250 600 {lab=P8}
N 260 605 2255 605 {lab=P7}
N 340 610 2260 610 {lab=P6}
N 435 620 2270 620 {lab=P4}
N 515 625 2275 625 {lab=P3}
N 565 630 2280 630 {lab=P2}
N 610 635 2285 635 {lab=P1}
N 2035 -135 2265 -135 {lab=P5}
N 910 -110 930 -110 {lab=V1p}
C {simp_SH.sym} -60 -100 0 0 {name=x1}
C {simple_comparator.sym} 1080 -80 0 0 {name=x2}
C {vsource.sym} -350 115 0 1 {name=V2 value="PULSE(0 3.3 215n 1n 1n 500n 1000n)" savecurrent=false}
C {vsource.sym} -300 180 0 0 {name=V5 value="sin(0 -1.65 200000)" savecurrent=false}
C {vsource.sym} -300 255 0 0 {name=V6 value=1.65 savecurrent=false}
C {vsource.sym} -225 40 0 0 {name=V7 value="sin(0 1.65 200000)" savecurrent=false}
C {vsource.sym} -390 185 0 1 {name=V3 value="PULSE(0 3.3 0 1n 1n 200n 1000n)" savecurrent=false}
C {gnd.sym} -225 310 0 0 {name=l3 lab=0}
C {lab_wire.sym} -250 -130 0 0 {name=p1 sig_type=std_logic lab=CLK_SH}
C {lab_wire.sym} -250 -110 0 0 {name=p2 sig_type=std_logic lab=notCLK_SH}
C {lab_wire.sym} -250 -90 0 0 {name=p3 sig_type=std_logic lab=Vinn}
C {lab_wire.sym} -225 -70 0 0 {name=p4 sig_type=std_logic lab=Vinp}
C {lab_wire.sym} 795 -110 0 0 {name=p5 sig_type=std_logic lab=V1n}
C {lab_wire.sym} 795 -70 0 0 {name=p6 sig_type=std_logic lab=V1p}
C {lab_wire.sym} 895 -130 0 0 {name=p7 sig_type=std_logic lab=CLK_comp}
C {lab_wire.sym} 1220 -105 0 0 {name=p8 sig_type=std_logic lab=VR}
C {lab_wire.sym} 1220 -55 0 0 {name=p9 sig_type=std_logic lab=VL}
C {lab_wire.sym} 1300 -90 0 0 {name=p10 sig_type=std_logic lab=Von}
C {lab_wire.sym} 1300 -70 0 0 {name=p11 sig_type=std_logic lab=Vop}
C {code_shown.sym} 700 65 0 0 {
name=TT_MODELS
only_toplevel=true
value="
** IHP models
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ

.param temp=27

.save v(CLK_SH) v(notCLK_SH) v(CLK_outputAll) v(CLK_resetOut)
.save v(Vinp) v(Vinn) v(v1p) v(V1n)
.save v(Von) v(Vop) v(Valid)
.save v(Ck9) v(Ck8) v(Ck7) v(Ck6) v(Ck5) v(Ck4) v(Ck3) v(Ck2) v(Ck1) v(Ck0)
.save v(P9) v(P8) v(P7) v(P6) v(P5) v(P4) v(P3) v(P2) v(P1) v(P0)
.save v(N9) v(N8) v(N7) v(N6) v(N5) v(N4) v(N3) v(N2) v(N1) v(N0)
.save v(P9_out) v(P8_out) v(P7_out) v(P6_out) v(P5_out) v(P4_out) v(P3_out) v(P2_out) v(P1_out) v(P0_out)
.save v(N9_out) v(N8_out) v(N7_out) v(N6_out) v(N5_out) v(N4_out) v(N3_out) v(N2_out) v(N1_out) v(N0_out)

.ic v(x1.clk_pnot) = 0
.tran 0.05n 2300n 

.control
set num_threads 1
run
write testWhole.raw
.endc
"
spice_ignore=false
      }
C {gnd.sym} 1345 50 0 0 {name=l1 lab=0}
C {sg13g2_pr/cap_cmim.sym} 165 -15 0 0 {name=C1
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=256
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 215 40 0 0 {name=C5
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=128
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 260 95 0 0 {name=C2
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=64
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 340 -15 0 0 {name=C3
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=32
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 390 40 0 0 {name=C4
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=16
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 435 95 0 0 {name=C6
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=8
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 515 -15 0 0 {name=C7
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=4
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 565 40 0 0 {name=C8
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=2
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 610 95 0 0 {name=C9
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=1
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 695 -15 0 0 {name=C10
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=1
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 185 -160 2 1 {name=C11
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=256
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 235 -215 2 1 {name=C12
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=128
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 280 -270 2 1 {name=C13
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=64
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 360 -160 2 1 {name=C14
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=32
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 410 -215 2 1 {name=C15
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=16
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 455 -270 2 1 {name=C16
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=8
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 535 -160 2 1 {name=C17
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=4
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 585 -215 2 1 {name=C18
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=2
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 630 -270 2 1 {name=C19
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=1
  mm_ok=1
 spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 715 -160 2 1 {name=C20
model=cap_cmim
 w=7.0e-6
 l=7.0e-6
 m=1
  mm_ok=1
 spiceprefix=X}
C {gnd.sym} 1910 -470 0 0 {name=l2 lab=0}
C {lab_wire.sym} 1965 185 0 0 {name=p12 sig_type=std_logic lab=P9_out}
C {lab_wire.sym} 1965 205 0 0 {name=p13 sig_type=std_logic lab=P8_out}
C {lab_wire.sym} 1965 225 0 0 {name=p14 sig_type=std_logic lab=P7_out}
C {lab_wire.sym} 1965 245 0 0 {name=p15 sig_type=std_logic lab=P6_out}
C {lab_wire.sym} 1965 265 0 0 {name=p16 sig_type=std_logic lab=P5_out}
C {lab_wire.sym} 1965 285 0 0 {name=p17 sig_type=std_logic lab=P4_out}
C {lab_wire.sym} 1965 305 0 0 {name=p18 sig_type=std_logic lab=P3_out}
C {lab_wire.sym} 1965 325 0 0 {name=p19 sig_type=std_logic lab=P2_out}
C {lab_wire.sym} 1965 345 0 0 {name=p20 sig_type=std_logic lab=P1_out}
C {lab_wire.sym} 1965 365 0 0 {name=p21 sig_type=std_logic lab=P0_out}
C {lab_wire.sym} 1965 385 0 0 {name=p22 sig_type=std_logic lab=N9_out}
C {lab_wire.sym} 1965 405 0 0 {name=p23 sig_type=std_logic lab=N8_out}
C {lab_wire.sym} 1965 425 0 0 {name=p24 sig_type=std_logic lab=N7_out}
C {lab_wire.sym} 1965 445 0 0 {name=p25 sig_type=std_logic lab=N6_out}
C {lab_wire.sym} 1965 465 0 0 {name=p26 sig_type=std_logic lab=N5_out}
C {lab_wire.sym} 1965 485 0 0 {name=p27 sig_type=std_logic lab=N4_out}
C {lab_wire.sym} 1965 505 0 0 {name=p28 sig_type=std_logic lab=N3_out}
C {lab_wire.sym} 1965 525 0 0 {name=p29 sig_type=std_logic lab=N2_out}
C {lab_wire.sym} 1965 545 0 0 {name=p30 sig_type=std_logic lab=N1_out}
C {lab_wire.sym} 1965 565 0 0 {name=p31 sig_type=std_logic lab=N0_out}
C {vsource.sym} 1400 5 0 1 {name=V4 value="PULSE(0 3.3 950n 1n 1n 5n 1000n)" savecurrent=false}
C {vsource.sym} 1470 125 0 1 {name=V9 value="PULSE(0 3.3 1100n 1n 1n 10n 1000n)" savecurrent=false}
C {gnd.sym} 1470 235 0 0 {name=l4 lab=0}
C {gnd.sym} 1400 115 0 0 {name=l5 lab=0}
C {lab_wire.sym} 1465 -25 0 0 {name=p32 sig_type=std_logic lab=CLK_outputAll}
C {lab_wire.sym} 1515 70 0 0 {name=p33 sig_type=std_logic lab=CLK_resetOut}
C {lab_wire.sym} 2235 -215 0 0 {name=p34 sig_type=std_logic lab=P9}
C {lab_wire.sym} 2235 -195 0 0 {name=p35 sig_type=std_logic lab=P8}
C {lab_wire.sym} 2235 -175 0 0 {name=p36 sig_type=std_logic lab=P7}
C {lab_wire.sym} 2235 -155 0 0 {name=p37 sig_type=std_logic lab=P6}
C {lab_wire.sym} 2235 -135 0 0 {name=p38 sig_type=std_logic lab=P5}
C {lab_wire.sym} 2235 -115 0 0 {name=p39 sig_type=std_logic lab=P4}
C {lab_wire.sym} 2235 -95 0 0 {name=p40 sig_type=std_logic lab=P3}
C {lab_wire.sym} 2235 -75 0 0 {name=p41 sig_type=std_logic lab=P2}
C {lab_wire.sym} 2235 -55 0 0 {name=p42 sig_type=std_logic lab=P1}
C {lab_wire.sym} 2235 -35 0 0 {name=p43 sig_type=std_logic lab=P0}
C {lab_wire.sym} 2235 165 0 0 {name=p44 sig_type=std_logic lab=N0}
C {lab_wire.sym} 2235 -15 0 0 {name=p45 sig_type=std_logic lab=N9}
C {lab_wire.sym} 2235 5 0 0 {name=p46 sig_type=std_logic lab=N8}
C {lab_wire.sym} 2235 25 0 0 {name=p47 sig_type=std_logic lab=N7}
C {lab_wire.sym} 2235 45 0 0 {name=p48 sig_type=std_logic lab=N6}
C {lab_wire.sym} 2235 65 0 0 {name=p49 sig_type=std_logic lab=N5}
C {lab_wire.sym} 2235 85 0 0 {name=p50 sig_type=std_logic lab=N4}
C {lab_wire.sym} 2235 105 0 0 {name=p51 sig_type=std_logic lab=N3}
C {lab_wire.sym} 2235 125 0 0 {name=p52 sig_type=std_logic lab=N2}
C {lab_wire.sym} 2235 145 0 0 {name=p53 sig_type=std_logic lab=N1}
C {lab_wire.sym} 1475 -475 0 0 {name=p54 sig_type=std_logic lab=Valid}
C {vsource.sym} -565 30 0 1 {name=V1 value=3.3 savecurrent=false}
C {simp_OR.sym} 1360 -230 0 0 {name=x4}
C {DFF_array2.sym} 1705 35 0 0 {name=x3}
C {lab_wire.sym} 2085 -455 0 0 {name=p55 sig_type=std_logic lab=Ck9}
C {lab_wire.sym} 2085 -435 0 0 {name=p56 sig_type=std_logic lab=Ck8}
C {lab_wire.sym} 2085 -415 0 0 {name=p57 sig_type=std_logic lab=Ck7}
C {lab_wire.sym} 2085 -395 0 0 {name=p58 sig_type=std_logic lab=Ck6}
C {lab_wire.sym} 2085 -375 0 0 {name=p59 sig_type=std_logic lab=Ck5}
C {lab_wire.sym} 2085 -355 0 0 {name=p60 sig_type=std_logic lab=Ck4}
C {lab_wire.sym} 2085 -335 0 0 {name=p61 sig_type=std_logic lab=Ck3}
C {lab_wire.sym} 2085 -315 0 0 {name=p62 sig_type=std_logic lab=Ck2}
C {lab_wire.sym} 2085 -295 0 0 {name=p63 sig_type=std_logic lab=Ck1}
C {lab_wire.sym} 2085 -275 0 0 {name=p64 sig_type=std_logic lab=Ck0}
C {capDrivers.sym} 1885 -125 0 0 {name=x5}
C {capDrivers.sym} 2045 75 0 0 {name=x6}
C {lab_wire.sym} -440 -245 0 0 {name=p65 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2140 -225 0 0 {name=p66 sig_type=std_logic lab=VDD}
C {gnd.sym} 2195 255 0 0 {name=l6 lab=0}
